# Keil uVision project Smart Bubble Machine.uvproj, settings and files
target Smart Bubble Machine (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: SBM
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY, __FPU_PRESENT=1,ARM_MATH_CM4
  c include: ..\inc;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Utilities\Third_Party\FatFs_vR0.08a;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Utilities\STM32F4-Discovery;..\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Utilities\Third_Party\helix;..\..\..\Utilities\Third_Party\helix\real;..\..\..\Utilities\Third_Party\helix\pub;..\..\..\Utilities\Third_Party\libmad\msvc++;..\..\..\Utilities\Third_Party\libmad
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c rtc.c functions.c interupts.c fsm.c i2c.c
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c croutine.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_sdio_sd.c stm32f4_discovery_debug.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group FATFS
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: diskio.c ff.c
